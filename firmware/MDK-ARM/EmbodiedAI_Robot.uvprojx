# Keil uVision project EmbodiedAI_Robot.uvprojx, settings and files
target EmbodiedAI_Robot (6240000::V6.24::ARMCLANG)
  device: STM32G474VCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: EmbodiedAI_Robot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Application/Algorithm;../Application/Driver;../Application/Device;../Application/Module;../Application/Module/SO101ARM;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Application/Task
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c hrtim.c i2c.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Driver
    ../Application/Driver/: drv_brush_motor.c drv_brush_motor.h driver.c driver.h DWT.c DWT.h drv_uart.c drv_uart.h drv_lift_home_sensor.c drv_lift_home_sensor.h drv_gas_sensor.c drv_gas_sensor.h drv_power_voltage.c drv_power_voltage.h drv_sht31.c drv_sht31.h
  group Device
    ../Application/Device/: dev_brush_motor.c dev_brush_motor.h dev_lift_home_sensor.c dev_lift_home_sensor.h ssd1306.c ssd1306.h ssd1306_conf.h ssd1306_fonts.c ssd1306_fonts.h dev_sts_servo.c dev_sts_servo.h dev_sts_servo_config.h dev_uart.h dev_gas_sensor.c dev_gas_sensor.h dev_power_voltage.c dev_power_voltage.h dev_sht31.c dev_sht31.h
  group Module
    ../Application/Module/: module.c module.h mdl_chassis.c mdl_chassis.h mdl_control_arbitration.c mdl_control_arbitration.h mdl_control_protocol.c mdl_control_protocol.h mdl_lift.c mdl_lift.h mdl_lift_config.h mdl_peripheral.c mdl_peripheral.h mdl_peripheral_config.h
    ../Application/Module/SO101ARM/: mdl_so101_arm.c mdl_so101_arm.h mdl_so101_arm_config.h so101_algorithm.c so101_algorithm.h
  group Task
    ../Application/Task/: task_arm.c task_arm.h task_chassis.c task_chassis.h task_command.c task_command.h task_demo.c task_demo.h demo_macro_config.h task_lift.c task_lift.h task_oled.c task_oled.h task_telemetry.c task_telemetry.h task_peripheral.c task_peripheral.h
  group Algorithm
    ../Application/Algorithm/: pid.c pid.h alg_crc8.c alg_crc8.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 6.1.0
